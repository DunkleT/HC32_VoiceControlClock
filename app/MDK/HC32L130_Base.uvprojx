# Keil uVision project HC32L130_Base.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32L130J8TA HDSC
  pack: HDSC.HC32L13x.1.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HC32L130_BaseV1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\driver\inc;..\..\mcu\common;..\source;..\source\bsp;..\source\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ../../mcu/common/: interrupts_hc32l13x.c system_hc32l13x.c
    ./: startup_hc32l13x.s
  group source
    ../source/: main.c
  group driver
    ../../driver/src/: spi.c ddl.c gpio.c sysctrl.c rtc.c flash.c bt.c tm1652.c uart.c i2c.c sht3x.c ds3231.c adt.c adc.c bgr.c timer3.c lpm.c
  group bsp
    ../source/bsp/: bsp_delay.c bsp_gpio.c bsp_flash.c bsp_uart.c bsp_pwm.c bsp_adc.c bsp_timer.c
  group app
    ../source/app/: segment.c pama.c
software components: CMSIS:CORE 5.5.0
